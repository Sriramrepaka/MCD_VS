** sch_path: xschem/ota-2stage_tb-tran.sch
**.subckt ota-2stage_tb-tran
Vdd v_dd GND 1.5
Vss v_ss GND 0
C1 v_out v_ss 1p m=1
Vin v_in v_ss dc 0 pwl(0 0 1u 0 1.1u 0.7)
I0 v_dd net1 dc 0 pwl(0 0 1.1u 0 1.2u 20u)
.save v(v_in)
.save v(v_out)
x1 v_dd net1 v_out v_out v_in v_ss ota-2stage
**** begin user architecture code
 .lib cornerMOSlv.lib mos_ss
.lib cornerCAP.lib cap_typ
.lib cornerRES.lib res_typ



.temp 27

.ic v(v_out)=0
.option method=gear

.control

* Overwrite Vin from the schematic with the active pulse parameter limits
* alter Vin PULSE(1.05 1.25 1u 1n 1n 20u 40u)

* Simulates up to 15us
tran 0.005u 15u


plot v_in v_out

let vout_limit=0.7*0.99
meas tran tcross WHEN v(v_out)=vout_limit
let vin_limit=0.8*0.7
meas tran tstart WHEN v(v_in)=vin_limit
let tsettle=tcross-tstart

print tstart
print tcross
print tsettle

* Convert from seconds to microseconds so CACE can log it under your 'us' unit spec!
let tsettle_us = tsettle * 1e6
*echo $&tsettle_us > CACE{simpath}/CACE{filename}_CACE{N}.data

.endc


**** end user architecture code
**.ends
.GLOBAL GND
.end
