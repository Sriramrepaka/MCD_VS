** sch_path: cace/templates/lpf-ota-2stage-ac.sch
* Copyright 2024 Harald Pretl
**.subckt lpf-ota-2stage-ac vdd vss vdd vss
*.iopin vdd
*.iopin vss
*.iopin vdd
*.iopin vss
Vdd v_dd GND CACE{vdd}
Vss v_ss GND 0
Vin v_in GND dc CACE{vin} ac 1
I0 vdd net1 CACE{ibias}
.save v(v_in)
.save v(v_out)
x1 vdd net1 v_out v_out net2 vss ota-2stage
R1 v_in net3 37.5MEG m=1
R2 net3 net2 37.5MEG m=1
C1 net2 GND 0.3p m=1
C2 net3 v_out 0.6p m=1
**** begin user architecture code


.include CACE{DUT_path}
.temp CACE{temp}
.param mc_ok = CACE{sigma=1}
.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]

.control
set num_threads=1

op
let dcgain=v(v_out)/v(v_in)

ac dec 101 10 1MEG
meas ac acgain MAX vmag(v_out) FROM=100 TO=1k
let f3db = acgain/sqrt(2)
meas ac fc WHEN vmag(v_out)=f3db FALL=1

echo $&op1.dcgain $&fc > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc



.lib cornerMOSlv.lib mos_CACE{corner}
.lib cornerMOShv.lib mos_CACE{corner}
.lib cornerRES.lib res_CACE{corner_res}
.lib cornerCAP.lib cap_CACE{corner_cap}

**** end user architecture code
**.ends
.GLOBAL GND
.end
