** sch_path: cace/templates/lpf-ota-2stage-tran.sch
* Copyright 2024 Harald Pretl
**.subckt lpf-ota-2stage-tran vdd vss vdd vss
*.iopin vdd
*.iopin vss
*.iopin vdd
*.iopin vss
Vdd vdd GND CACE{vdd}
Vss vss GND 0
Vin v_in GND dc 0 pwl(0 0 1u 0 1.1u CACE{vin})
I0 vdd net1 CACE{ibias}
.save v(v_in)
.save v(v_out)
x1 vdd net1 v_out v_out net2 vss ota-2stage
R1 v_in net3 37.5MEG m=1
R2 net3 net2 37.5MEG m=1
C1 net2 GND 0.3p m=1
C2 net3 v_out 0.6p m=1
**** begin user architecture code


.include CACE{DUT_path}
.temp CACE{temp}
.param mc_ok = CACE{sigma=1}
.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]

.ic v(v_out)=0
.option method=gear

.control
set num_threads=1
tran 0.1u 500u

let vout_limit=CACE{vin}*0.99
meas tran tcross WHEN v(v_out)=vout_limit
let vin_limit=0.8*CACE{vin}
meas tran tstart WHEN v(v_in)=vin_limit
let tsettle=tcross-tstart

echo $&tsettle > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc



.lib cornerMOSlv.lib mos_CACE{corner}
.lib cornerMOShv.lib mos_CACE{corner}
.lib cornerRES.lib res_CACE{corner_res}
.lib cornerCAP.lib cap_CACE{corner_cap}

**** end user architecture code
**.ends
.GLOBAL GND
.end
