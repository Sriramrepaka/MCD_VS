** sch_path: cace/templates/lr4-ota-2stage-tran.sch
**.subckt lr4-ota-2stage-tran vdd vdd vss vdd vdd vss vdd vdd vss vdd vdd vss vdd vss
*.iopin vdd
*.iopin vdd
*.iopin vss
*.iopin vdd
*.iopin vdd
*.iopin vss
*.iopin vdd
*.iopin vdd
*.iopin vss
*.iopin vdd
*.iopin vdd
*.iopin vss
*.iopin vdd
*.iopin vss
I0 vdd net1 CACE{ibias}
Vin v_in GND dc CACE{vin} ac 1
x1 vdd net1 net3 net3 net4 vss ota-2stage
R1 net3 net2 18.7MEG m=1
R2 net5 net4 37.4MEG m=1
C1 net2 v_in 0.6p m=1
C2 net4 net2 0.6p m=1
V1 net5 GND dc CACE{vin}
I1 vdd net6 CACE{ibias}
R3 v_in net7 37.5MEG m=1
R4 net7 net8 37.5MEG m=1
C3 net8 GND 0.3p m=1
C4 net7 net9 0.6p m=1
x2 vdd net6 net9 net9 net8 vss ota-2stage
I2 vdd net10 CACE{ibias}
R5 net9 net11 37.5MEG m=1
R6 net11 net12 37.5MEG m=1
C5 net12 GND 0.3p m=1
C6 net11 v_lpf 0.6p m=1
x3 vdd net10 v_lpf v_lpf net12 vss ota-2stage
I3 vdd net13 CACE{ibias}
x4 vdd net13 v_hpf v_hpf net15 vss ota-2stage
R7 v_hpf net14 18.7MEG m=1
R8 net16 net15 37.4MEG m=1
C7 net14 net3 0.6p m=1
C8 net15 net14 0.6p m=1
V2 net16 GND dc CACE{vin}
Vdd vdd GND CACE{vdd}
Vss vss GND 0
**** begin user architecture code

.lib cornerMOSlv.lib mos_CACE{corner}
.lib cornerMOShv.lib mos_CACE{corner}
.lib cornerRES.lib res_CACE{corner_res}
.lib cornerCAP.lib cap_CACE{corner_cap}



.include CACE{DUT_path}
.temp CACE{temp}
.param mc_ok = CACE{sigma=1}
.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]

.ic v(v_lpf)=0
.ic v(v_hpf)=0
.option method=gear

.control
set num_threads=1
tran 0.1u 280u uic

let vin_limit=CACE{vin}
meas tran tstart WHEN v(v_in)=vin_limit

meas tran v_final_lpf FIND v(v_lpf) AT=200u
meas tran v_final_hpf FIND v(v_hpf) AT=200u

meas tran tcross_lpf WHEN v(v_lpf)={v_final_lpf + (CACE{vin}*0.01)} LAST

meas tran tcross_hpf WHEN v(v_hpf)={v_final_hpf - (CACE{vin}*0.01)} LAST

let tsettle_lpf=tcross_lpf-tstart
let tsettle_hpf=tcross_hpf-tstart

echo $&tsettle_lpf $&tsettle_hpf > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends
.GLOBAL GND
.end
