** sch_path: cace/templates/ota-2stage-tran.sch
* Copyright 2024-2025 Harald Pretl
**.subckt ota-2stage-tran
Vdd v_dd GND CACE{vdd}
Vss v_ss GND 0
C1 v_out v_ss CACE{cload} m=1
Vin v_in v_ss dc 0 pwl(0 0 1u 0 1.1u CACE{vin})
I0 v_dd net1 dc 0 pwl(0 0 1.1u 0 1.2u CACE{ibias})
.save v(v_in)
.save v(v_out)
x1 v_dd net1 v_out v_out v_in v_ss ota-2stage
**** begin user architecture code


.include CACE{DUT_path}
.temp CACE{temp}
.param mc_ok = CACE{sigma=1}
.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]

.ic v(v_out)=0
.option method=gear

.control
set num_threads=1
tran 0.005u 15u

let vout_limit=CACE{vin}*0.99
meas tran tcross WHEN v(v_out)=vout_limit
let vin_limit=0.5*CACE{vdd}
meas tran tstart WHEN v(v_in)=vin_limit
let tsettle=tcross-tstart

echo $&tsettle > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc



.lib cornerMOSlv.lib mos_CACE{corner}
.lib cornerMOShv.lib mos_CACE{corner}
.lib cornerRES.lib res_CACE{corner_res}
.lib cornerCAP.lib cap_CACE{corner_cap}

**** end user architecture code
**.ends
.GLOBAL GND
.end
