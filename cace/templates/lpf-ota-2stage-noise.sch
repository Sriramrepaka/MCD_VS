** sch_path: cace/templates/lpf-ota-2stage-noise.sch
* Copyright 2024 Harald Pretl
**.subckt lpf-ota-2stage-noise vdd vss vdd vss
*.iopin vdd
*.iopin vss
*.iopin vdd
*.iopin vss
Vdd v_dd GND CACE{vdd}
Vss v_ss GND 0
Vin v_in GND dc CACE{vin} ac 1
I0 vdd net1 CACE{ibias}
.save v(v_in)
.save v(v_out)
x1 vdd net1 v_out v_out net2 vss ota-2stage
R1 v_in net3 37.5MEG m=1
R2 net3 net2 37.5MEG m=1
C1 net2 GND 0.3p m=1
C2 net3 v_out 0.6p m=1
**** begin user architecture code


.include CACE{DUT_path}
.temp CACE{temp}
.param mc_ok = CACE{sigma=1}
.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]
.option sparse

.control
set num_threads=1
save all
noise v(v_out) Vin dec 101 1k 1MEG

let noise=onoise_total
echo $&noise > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc



.lib cornerMOSlv.lib mos_CACE{corner}
.lib cornerMOShv.lib mos_CACE{corner}
.lib cornerRES.lib res_CACE{corner_res}
.lib cornerCAP.lib cap_CACE{corner_cap}

**** end user architecture code
**.ends
.GLOBAL GND
.end
